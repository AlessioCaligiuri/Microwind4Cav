CIRCUIT C:\Users\emanu\Documents\A_UNIVERSITA\A_MAGISTRALE\Microwind4Cav\NotCarryGenerator\NotCarryGenerator.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
*
* List of nodes
* "notCarry" corresponds to n°4
* "N5" corresponds to n°5
* "N6" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "b" corresponds to n°15
* "a" corresponds to n°16
* "c" corresponds to n°18
*
* Generators for a b c
Va 16 0 PULSE(0 1.2 0 10p 10p 500p 1n)
Vb 15 0 PULSE(0 1.2 0 10p 10p 1n 2n)
Vc 18 0 PULSE(0 1.2 0 10p 10p 2n 4n)
*
* Output capacitor
Cout 4 0 2fF
*
* MOS devices
MN1 10 15 0 0 N1  W= 1.56U L= 0.12U
MN2 4 16 10 0 N1  W= 1.56U L= 0.12U
MN3 11 16 4 0 N1  W= 0.48U L= 0.12U
MN4 12 15 4 0 N1  W= 0.48U L= 0.12U
MN5 0 18 11 0 N1  W= 0.48U L= 0.12U
MN6 0 18 12 0 N1  W= 0.48U L= 0.12U
MN7 13 18 0 0 N1  W= 0.48U L= 0.12U
MN8 14 18 0 0 N1  W= 0.48U L= 0.12U
MN9 4 16 13 0 N1  W= 0.48U L= 0.12U
MN10 4 15 14 0 N1  W= 0.48U L= 0.12U
MP1 5 15 4 1 P1  W= 3.48U L= 0.12U
MP2 1 16 5 1 P1  W= 3.48U L= 0.12U
MP3 6 16 1 1 P1  W= 1.44U L= 0.12U
MP4 7 15 1 1 P1  W= 1.44U L= 0.12U
MP5 4 18 6 1 P1  W= 1.44U L= 0.12U
MP6 4 18 7 1 P1  W= 1.44U L= 0.12U
MP7 8 18 4 1 P1  W= 1.44U L= 0.12U
MP8 9 18 4 1 P1  W= 1.44U L= 0.12U
MP9 1 16 8 1 P1  W= 1.44U L= 0.12U
MP10 1 15 9 1 P1  W= 1.44U L= 0.12U
*
C2 1 0  7.140fF
C4 4 0  2.810fF
C5 5 0  0.554fF
C6 6 0  0.240fF
C7 7 0  0.240fF
C8 8 0  0.240fF
C9 9 0  0.240fF
C10 10 0  0.272fF
C11 11 0  0.096fF
C12 12 0  0.096fF
C13 13 0  0.096fF
C14 14 0  0.096fF
C15 15 0  0.795fF
C16 16 0  0.464fF
C17 16 0  0.279fF
C18 18 0  0.202fF
C19 18 0  0.386fF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.tran 0 10n 0 1p
.PROBE
.END
