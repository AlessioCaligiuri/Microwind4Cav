CIRCUIT D:\INGEGNERIA\Microelectronics\Microwind4Cav\TSPC_FA_FullDesign\TSPC_FA_FullDesign.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
*
* List of nodes
* "SUM" corresponds to n°4
* "nSUM" corresponds to n°5
* "CARRY" corresponds to n°6
* "N7" corresponds to n°7
* "nCARRY" corresponds to n°8
* "N9" corresponds to n°9
* "d" corresponds to n°19
* "B" corresponds to n°28
* "C" corresponds to n°29
* "PHI" corresponds to n°30
* "A" corresponds to n°31
*
* Generators for a b c
Va inA 0 PULSE(0 1.2 375p 10p 10p 500p 1n)
Vb inB 0 PULSE(0 1.2 375p 10p 10p 1n 2n)
Vc inC 0 PULSE(0 1.2 375p 10p 10p 2n 4n)
*
* Generator for phi
Vphi PHI 0 PULSE(0 1.2 0 10p 10p 250p 500p)
*
* Output capacitors
CoutSum SUM 0 100fF
CoutCarry CARRY 0 100fF
*
* MOS devices
MN1 0 inA 18 0 N1  W= 1.92U L= 0.12U
MN2 18 inB 17 0 N1  W= 1.92U L= 0.12U
MN3 17 inC 16 0 N1  W= 1.92U L= 0.12U
MN4 16 PHI 5 0 N1  W= 1.92U L= 0.12U
MN5 0 5 15 0 N1  W= 0.96U L= 0.12U
MN6 15 PHI SUM 0 N1  W= 0.96U L= 0.12U
MN7 SUM PHI 14 0 N1  W= 0.96U L= 0.12U
MN8 14 5 0 0 N1  W= 0.96U L= 0.12U
MN9 19 inA 5 0 N1  W= 1.20U L= 0.12U
MN10 5 inB 19 0 N1  W= 1.20U L= 0.12U
MN11 19 inC 5 0 N1  W= 1.20U L= 0.12U
MN12 20 8 19 0 N1  W= 1.20U L= 0.12U
MN13 0 PHI 20 0 N1  W= 1.20U L= 0.12U
MN14 21 8 0 0 N1  W= 1.20U L= 0.12U
MN15 CARRY PHI 21 0 N1  W= 1.20U L= 0.12U
MN16 22 PHI CARRY 0 N1  W= 1.20U L= 0.12U
MN17 0 8 22 0 N1  W= 1.20U L= 0.12U
MN18 23 inB 0 0 N1  W= 1.56U L= 0.12U
MN19 8 inA 23 0 N1  W= 1.56U L= 0.12U
MN20 24 inA 8 0 N1  W= 0.48U L= 0.12U
MN21 25 inB 8 0 N1  W= 0.48U L= 0.12U
MN22 0 inC 24 0 N1  W= 0.48U L= 0.12U
MN23 0 inC 25 0 N1  W= 0.48U L= 0.12U
MN24 26 inC 0 0 N1  W= 0.48U L= 0.12U
MN25 27 inC 0 0 N1  W= 0.48U L= 0.12U
MN26 8 inA 26 0 N1  W= 0.48U L= 0.12U
MN27 8 inB 27 0 N1  W= 0.48U L= 0.12U
MP1 1 5 SUM 1 P1  W= 3.60U L= 0.12U
MP2 1 PHI 5 1 P1  W= 1.20U L= 0.12U
MP3 1 8 CARRY 1 P1  W= 3.60U L= 0.12U
MP4 7 inB 1 1 P1  W= 1.44U L= 0.12U
MP5 8 inA 7 1 P1  W= 1.44U L= 0.12U
MP6 9 inA 8 1 P1  W= 1.44U L= 0.12U
MP7 1 inB 9 1 P1  W= 1.44U L= 0.12U
MP8 10 inB 1 1 P1  W= 1.44U L= 0.12U
MP9 8 inC 10 1 P1  W= 1.44U L= 0.12U
MP10 11 inC 8 1 P1  W= 1.44U L= 0.12U
MP11 1 inB 11 1 P1  W= 1.44U L= 0.12U
MP12 12 inA 1 1 P1  W= 1.44U L= 0.12U
MP13 8 inC 12 1 P1  W= 1.44U L= 0.12U
MP14 13 inC 8 1 P1  W= 1.44U L= 0.12U
MP15 1 inA 13 1 P1  W= 1.44U L= 0.12U
*
C2 1 0 12.268fF
C4 SUM 0  1.282fF
C5 5 0  2.578fF
C6 CARRY 0  1.575fF
C7 7 0  0.240fF
C8 8 0  3.357fF
C9 9 0  0.240fF
C10 10 0  0.240fF
C11 11 0  0.240fF
C12 12 0  0.240fF
C13 13 0  0.240fF
C14 14 0  0.174fF
C15 15 0  0.174fF
C16 16 0  0.424fF
C17 17 0  0.331fF
C18 18 0  0.331fF
C19 19 0  0.781fF
C20 20 0  0.214fF
C21 21 0  0.214fF
C22 22 0  0.214fF
C23 23 0  0.272fF
C24 24 0  0.096fF
C25 25 0  0.096fF
C26 26 0  0.096fF
C27 27 0  0.096fF
C28 inB 0  2.295fF
C29 inC 0  2.052fF
C30 PHI 0  1.947fF
C31 inA 0  2.134fF
C32 32 0  0.045fF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.tran 0 5n 0 1p
.PROBE
.END
